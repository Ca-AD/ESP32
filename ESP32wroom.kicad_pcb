# Repository Ca-AD/ESP32

## KiCad design ESP32wroom.kicad_pcb

Parts:
C1, C3, C5, C7, C9, C10: 0.1uF; C_0603_1608Metric
C2, C6, C8: 10uF; C_0603_1608Metric
D1, D2: LED; LED_0603_1608Metric
D6: SS14; Nexperia_CFP3_SOD-123W
J1, J3: Conn_01x16; PinSocket_1x16_P2.54mm_Vertical
J2: USB_C_Receptacle_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12
Q1, Q2: S8050; SC-59
R1: R; R_0603_1608Metric
R4, R5, R6: 10K; R_0603_1608Metric
R7, R8: 5.1K; C_0603_1608Metric
R9: 470R; R_0603_1608Metric
R10, R11: 5K; R_0603_1608Metric
R12: 10K(NC); R_0603_1608Metric
SW1, SW2: SW_SPST; SW_SPST_B3U-1000P
U1: ESP32-WROOM-32
U2: AMS1117-3.3; SOT-223-3_TabPin2
U3: CH340C; SOIC-16_3.9x9.9mm_P1.27mm
U4: CH9102F; QFN-24-1EP_4x4mm_P0.5mm_EP2.6x2.6mm

Connections:
+3V3: C2.1, C3.1, C9.1, J1.1, R6.2, R9.1, R10.1, R12.2, U1.2 (VDD), U2.2 (VO), U3.4 (V3), U3.16 (VCC), U4.5 (VIO), U4.6 (V3)
+5V: C1.1, C5.2, C6.2, C8.2, D6.1 (K), J1.16, R1.1, U2.3 (VI), U4.7 (VDD5), U4.8 (VBUS)
/DTR: Q1.1 (E), R4.2, U3.13 (~DTR), U4.23 (~DTR)
/EN: C7.2, C10.1, J1.2, Q2.3 (C), R6.1, SW2.2 (B), U1.3 (EN)
/GPIO4: U4.16 (GPIO4)
/IO0: J3.13, Q1.3 (C), R10.2, SW1.2 (B), U1.25 (IO0)
/IO2: J3.14, R11.1, U1.24 (IO2)
/IO4: J3.12, U1.26 (IO4)
/IO5: J3.9, U1.29 (IO5)
/IO12: J1.13, U1.14 (IO12)
/IO13: D1.1 (K), J1.14, U1.16 (IO13)
/IO14: J1.12, U1.13 (IO14)
/IO15: J3.15, U1.23 (IO15)
/IO16: J3.11, U1.27 (IO16)
/IO17: J3.10, U1.28 (IO17)
/IO18: J3.8, U1.30 (IO18)
/IO19: J3.7, U1.31 (IO19)
/IO21: J3.6, U1.33 (IO21)
/IO22: J3.3, U1.36 (IO22)
/IO23: J3.2, U1.37 (IO23)
/IO25: J1.9, U1.10 (IO25)
/IO26: J1.10, U1.11 (IO26)
/IO27: J1.11, U1.12 (IO27)
/IO32: J1.7, U1.8 (IO32)
/IO33: J1.8, U1.9 (IO33)
/IO34: J1.5, U1.6 (IO34)
/IO35: J1.6, U1.7 (IO35)
/RTS: Q2.1 (E), R5.2, U3.14 (~RTS), U4.19 (~RTS)
/RXD: J3.4, U1.35 (TXD0/IO1), U3.3 (RXD), U4.20 (RXD)
/RXS/GPIO1: U4.13 (RXS/GPIO1)
/SCK/CLK: U1.20 (SCK/CLK)
/SCS/CMD: U1.19 (SCS/CMD)
/SDI/SD1: U1.22 (SDI/SD1)
/SDO/SD0: U1.21 (SDO/SD0)
/SENSOR_VN: J1.4, U1.5 (SENSOR_VN)
/SENSOR_VP: J1.3, U1.4 (SENSOR_VP)
/SHD/SD2: U1.17 (SHD/SD2)
/SUSPEND: U4.17 (SUSPEND)
/SWP/SD3: U1.18 (SWP/SD3)
/TNOW/GPIO2: U4.12 (TNOW/GPIO2)
/TXD: J3.5, U1.34 (RXD0/IO3), U3.2 (TXD), U4.21 (TXD)
/TXS/GPIO0: U4.14 (TXS/GPIO0)
/USB_DN: J2.A7 (D-), J2.B7 (D-), U3.6 (UD-), U4.4 (D-)
/USB_DP: J2.A6 (D+), J2.B6 (D+), U3.5 (UD+), U4.3 (D+)
/~ACT: U4.10 (~ACT)
/~CTS: U4.18 (~CTS)
/~DCD: U4.24 (~DCD)
/~DSR: U4.22 (~DSR)
/~RI: U4.1 (~RI)
/~RST: R12.1, U4.9 (~RST)
/~SUSPEND: U4.15 (~SUSPEND)
/~WAKEUP/GPIO3: U4.11 (~WAKEUP/GPIO3)
GND: C1.2, C2.2, C3.2, C5.1, C6.1, C7.1, C8.1, C9.2, C10.2, D2.1 (K), J1.15, J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.S1 (SHIELD), J3.1, J3.16, R7.2, R8.2, R11.2, SW1.1 (A), SW2.1 (A), U1.1 (GND), U1.15 (GND), U1.38 (GND), U1.39 (GND), U2.1 (GND), U4.2 (GND), U4.25 (GND)
unnamed: D1.2 (A), R9.2
unnamed: D2.2 (A), R1.2
unnamed: D6.2 (A), J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS)
unnamed: J2.A5 (CC1), R7.1
unnamed: J2.B5 (CC2), R8.1
unnamed: Q1.2 (B), R5.1
unnamed: Q2.2 (B), R4.1

Notes on the sheet:
此项目使用CH9102，没有使用CH340C
Diode_SMD:Nexperia_CFP3_SOD-123W
Connector_PinSocket_2.54mm:PinSocket_1x19_P2.54mm_Vertical

Board: 2 copper layers, 37.5 x 51.8 mm, 32 parts (0 on the bottom side), 42 nets.

## Commit log

2024-03-27 AD
    PCB
